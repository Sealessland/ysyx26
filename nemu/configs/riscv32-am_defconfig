## nemu/configs/riscv32-am_defconfig
```kconfig
CONFIG_TARGET_AM=y
# CONFIG_TRACE is not set
CONFIG_MSIZE=0x2000000
CONFIG_DEVICE=y
CONFIG_ITRACE=y
CONFIG_ITRACE_RING=y
CONFIG_ITRACE_COND=y
```
